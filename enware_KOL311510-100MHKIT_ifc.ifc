Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2020-03-26T19:04:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 26 19:04:54 2020 * Host: PC-015 * Database: C:\Users\PC--015\AppData\Local\Temp\{14A702D9-D5FD-4C07-BC11-DBE67D6F6FFB}\ifc * Database version: 5507 * Database creation date: Thu Mar 26 19:04:54 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 26 19:04:54 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 26 19:04:54 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: KOL311510-100MHKIT, KOL311510-100MHKIT:KOL311510-100MHKIT:203659
In: Level 1
Type - Identity Data - Type Name: KOL311510-100MHKIT
Type - Other - Category: Generic Models; Family Name: KOL311510-100MHKIT
Pset_BuildingElementProxyCommon - Reference: KOL311510-100MHKIT
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.55819 m2; Volume: 0.0329228 m3
Other - Family: KOL311510-100MHKIT: KOL311510-100MHKIT; Family and Type: KOL311510-100MHKIT: KOL311510-100MHKIT; Type: KOL311510-100MHKIT: KOL311510-100MHKIT; Type Id: KOL311510-100MHKIT: KOL311510-100MHKIT
Phasing - Phase Created: New Construction
